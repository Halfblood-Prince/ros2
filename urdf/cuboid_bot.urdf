Commit message: Fixed most of the issues

File: urdf/cuboid_bot.urdf (robot description, URDF)
Before this commit: robot cuboid_bot, 2 links, 1 joints
Links:
- link base_link: mass 2.0 -> 2
- link lidar_link: geometry visual cylinder length=0.05 radius=0.05
